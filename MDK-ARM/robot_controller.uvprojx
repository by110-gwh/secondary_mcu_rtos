# Keil uVision project robot_controller.uvprojx, settings and files
target robot_controller (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x10000) IROM2(0x00200000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: robot_controller +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ..\CMSIS;..\DRIVER;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM7\r0p1;..\STM32F7xx_HAL_Driver\Inc;..\SYSTEM;..\USB\hid;..\USB\STM32_USB_Device_Library\Class\CustomHID\Inc;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\USB_DEVICE;..\TASK;..\MODULE;..\USMART;..\MATH
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x1000000
  memory RVCT5: ROM 0x200000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group driver
    ../DRIVER/: steering_pwm.c debug_uart.c time_cnt.c mpu6050.c i2c.c qspi.c
  group freertos
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group math
    ../MATH/: Filter.c pid.c
  group module
    ../MODULE/: ahrs.c imu.c paramer_save.c
  group stlib
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_usb.c
  group system
    ../SYSTEM/: main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c system_stm32f7xx.c
    ../CMSIS/: startup_stm32f750xx.s
  group task
    ../TASK/: steering_task.c steering_action_task.c steering_updata_task.c main_task.c usmart_task.c ahrs_task.c imu_temp_task.c
  group usb
    ../USB/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../USB/USB_DEVICE/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
  group usmart
    ../USMART/: usmart.c usmart_config.c usmart_str.c
